# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32H750xx, __CLK_TCK=RT_TICK_PER_SECOND, STM32H7, __RTTHREAD__, USE_HAL_DRIVER, RT_USING_ARM_LIBC
  c include: applications;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\extension;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\touch;rt-thread\components\drivers\include;board;board\port;board\CubeMX_Config\Core\Inc;libraries\drivers;libraries\drivers\include;libraries\drivers\include\config;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\finsh;packages\gt9147-v1.0.0\inc;.;rt-thread\include;packages\LVGL-v8.2.0\src;packages\LVGL-v8.2.0\src\core;packages\LVGL-v8.2.0\src\draw;packages\LVGL-v8.2.0\src\extra;packages\LVGL-v8.2.0\src\font;packages\LVGL-v8.2.0\src\gpu;packages\LVGL-v8.2.0\src\hal;packages\LVGL-v8.2.0\src\misc;packages\LVGL-v8.2.0\src\widgets;packages\LVGL-v8.2.0\src\draw\nxp_pxp;packages\LVGL-v8.2.0\src\draw\nxp_vglite;packages\LVGL-v8.2.0\src\draw\sdl;packages\LVGL-v8.2.0\src\draw\stm32_dma2d;packages\LVGL-v8.2.0\src\draw\sw;packages\LVGL-v8.2.0\src\extra\layouts;packages\LVGL-v8.2.0\src\extra\libs;packages\LVGL-v8.2.0\src\extra\others;packages\LVGL-v8.2.0\src\extra\themes;packages\LVGL-v8.2.0\src\extra\widgets;packages\LVGL-v8.2.0\src\extra\layouts\flex;packages\LVGL-v8.2.0\src\extra\layouts\grid;packages\LVGL-v8.2.0\src\extra\libs\bmp;packages\LVGL-v8.2.0\src\extra\libs\ffmpeg;packages\LVGL-v8.2.0\src\extra\libs\freetype;packages\LVGL-v8.2.0\src\extra\libs\fsdrv;packages\LVGL-v8.2.0\src\extra\libs\gif;packages\LVGL-v8.2.0\src\extra\libs\png;packages\LVGL-v8.2.0\src\extra\libs\qrcode;packages\LVGL-v8.2.0\src\extra\libs\rlottie;packages\LVGL-v8.2.0\src\extra\libs\sjpg;packages\LVGL-v8.2.0\src\extra\others\gridnav;packages\LVGL-v8.2.0\src\extra\others\monkey;packages\LVGL-v8.2.0\src\extra\others\snapshot;packages\LVGL-v8.2.0\src\extra\themes\basic;packages\LVGL-v8.2.0\src\extra\themes\default;packages\LVGL-v8.2.0\src\extra\themes\mono;packages\LVGL-v8.2.0\src\extra\widgets\animimg;packages\LVGL-v8.2.0\src\extra\widgets\calendar;packages\LVGL-v8.2.0\src\extra\widgets\chart;packages\LVGL-v8.2.0\src\extra\widgets\colorwheel;packages\LVGL-v8.2.0\src\extra\widgets\imgbtn;packages\LVGL-v8.2.0\src\extra\widgets\keyboard;packages\LVGL-v8.2.0\src\extra\widgets\led;packages\LVGL-v8.2.0\src\extra\widgets\list;packages\LVGL-v8.2.0\src\extra\widgets\menu;packages\LVGL-v8.2.0\src\extra\widgets\meter;packages\LVGL-v8.2.0\src\extra\widgets\msgbox;packages\LVGL-v8.2.0\src\extra\widgets\span;packages\LVGL-v8.2.0\src\extra\widgets\spinbox;packages\LVGL-v8.2.0\src\extra\widgets\spinner;packages\LVGL-v8.2.0\src\extra\widgets\tabview;packages\LVGL-v8.2.0\src\extra\widgets\tileview;packages\LVGL-v8.2.0\src\extra\widgets\win;applications\lvgl;packages\LVGL-v8.2.0\env_support\rt-thread;libraries\samples;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;libraries\STM32H7xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\STM32H750XBHx\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: time.c stdlib.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c backtrace.c
    rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/ipc/: dataqueue.c completion.c ringblk_buf.c workqueue.c ringbuffer.c pipe.c waitqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    board/port/: filesystem.c
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    board/: board.c drv_mpu.c
    libraries/drivers/: drv_gpio.c drv_touch.c drv_spi.c drv_sdram.c drv_soft_i2c.c drv_wlan.c drv_sdio.c drv_lcd.c drv_usart.c drv_common.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_file.c cmd.c
  group gt9147
    packages/gt9147-v1.0.0/src/: gt9147.c
  group Kernel
    rt-thread/src/: clock.c kservice.c scheduler.c mempool.c idle.c timer.c device.c memheap.c ipc.c irq.c object.c components.c thread.c
  group LVGL
    packages/LVGL-v8.2.0/src/misc/: lv_area.c lv_log.c lv_color.c lv_style_gen.c lv_ll.c lv_lru.c lv_math.c lv_templ.c lv_timer.c lv_async.c lv_txt_ap.c lv_tlsf.c lv_mem.c lv_printf.c lv_style.c lv_anim_timeline.c lv_bidi.c lv_fs.c lv_anim.c lv_gc.c lv_txt.c lv_utils.c
    packages/LVGL-v8.2.0/src/widgets/: lv_img.c lv_objx_templ.c lv_label.c lv_btn.c lv_arc.c lv_dropdown.c lv_table.c lv_bar.c lv_canvas.c lv_btnmatrix.c lv_roller.c lv_checkbox.c lv_textarea.c lv_switch.c lv_slider.c lv_line.c
    packages/LVGL-v8.2.0/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.2.0/src/core/: lv_theme.c lv_obj_style.c lv_obj_pos.c lv_event.c lv_obj_scroll.c lv_obj_draw.c lv_obj_style_gen.c lv_refr.c lv_obj.c lv_disp.c lv_indev.c lv_group.c lv_obj_class.c lv_obj_tree.c lv_indev_scroll.c
    packages/LVGL-v8.2.0/src/font/: lv_font_montserrat_28.c lv_font_unscii_16.c lv_font_montserrat_34.c lv_font_montserrat_46.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_18.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_40.c lv_font_simsun_16_cjk.c lv_font_montserrat_28_compressed.c lv_font_montserrat_44.c lv_font_montserrat_14.c lv_font_montserrat_36.c lv_font_montserrat_12_subpx.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_12.c lv_font.c lv_font_unscii_8.c lv_font_montserrat_48.c lv_font_montserrat_16.c lv_font_montserrat_26.c lv_font_montserrat_42.c lv_font_montserrat_30.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_38.c lv_font_montserrat_32.c lv_font_montserrat_20.c
    packages/LVGL-v8.2.0/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    packages/LVGL-v8.2.0/src/extra/: lv_extra.c
    packages/LVGL-v8.2.0/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.2.0/src/draw/sw/: lv_draw_sw_polygon.c lv_draw_sw_blend.c lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_rect.c lv_draw_sw_gradient.c lv_draw_sw_line.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_dither.c
    packages/LVGL-v8.2.0/src/draw/: lv_draw_rect.c lv_draw.c lv_draw_img.c lv_draw_arc.c lv_img_cache.c lv_draw_line.c lv_img_buf.c lv_draw_mask.c lv_img_decoder.c lv_draw_triangle.c lv_draw_label.c
    packages/LVGL-v8.2.0/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.2.0/src/draw/sdl/: lv_draw_sdl_stack_blur.c lv_draw_sdl_utils.c lv_draw_sdl_polygon.c lv_draw_sdl_mask.c lv_draw_sdl_label.c lv_draw_sdl_texture_cache.c lv_draw_sdl_line.c lv_draw_sdl_bg.c lv_draw_sdl_arc.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_rect.c lv_draw_sdl.c
    packages/LVGL-v8.2.0/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.2.0/src/extra/libs/fsdrv/: lv_fs_stdio.c lv_fs_fatfs.c lv_fs_win32.c lv_fs_posix.c
    packages/LVGL-v8.2.0/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.2.0/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    packages/LVGL-v8.2.0/src/draw/nxp_pxp/: lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c
    packages/LVGL-v8.2.0/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.2.0/src/hal/: lv_hal_disp.c lv_hal_tick.c lv_hal_indev.c
    packages/LVGL-v8.2.0/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.2.0/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.2.0/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.2.0/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.2.0/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.2.0/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.2.0/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.2.0/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.2.0/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.2.0/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/LVGL-v8.2.0/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.2.0/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.2.0/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.2.0/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.2.0/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.2.0/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.2.0/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.2.0/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.2.0/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.2.0/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.2.0/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.2.0/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.2.0/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.2.0/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.2.0/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.2.0/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.2.0/src/extra/widgets/animimg/: lv_animimg.c
  group LVGL-demo
    packages/lv_music_demo-v0.2.0/assets/: img_lv_demo_rtt_music_btn_rnd.c img_lv_demo_rtt_music_icon_4.c img_lv_demo_rtt_music_icon_1.c img_lv_demo_rtt_music_cover_3.c img_lv_demo_rtt_music_logo.c img_lv_demo_rtt_music_btn_play.c img_lv_demo_rtt_music_wave_top.c img_lv_demo_rtt_music_wave_bottom.c img_lv_demo_rtt_music_btn_loop.c img_lv_demo_rtt_music_btn_next.c img_lv_demo_rtt_music_btn_list_play.c img_lv_demo_rtt_music_corner_left.c img_lv_demo_rtt_music_icon_3.c img_lv_demo_rtt_music_list_border.c img_lv_demo_rtt_music_btn_pause.c img_lv_demo_rtt_music_cover_1.c img_lv_demo_rtt_music_icon_2.c img_lv_demo_rtt_music_btn_prev.c img_lv_demo_rtt_music_cover_2.c img_lv_demo_rtt_music_corner_right.c img_lv_demo_rtt_music_btn_list_pause.c img_lv_demo_rtt_music_slider_knob.c
    packages/lv_music_demo-v0.2.0/: lv_demo_rtt_music_list.c lv_demo_rtt_music_main.c lv_demo_rtt_music.c
  group LVGL-port
    applications/lvgl/: lv_port_indev.c lv_demo.c lv_port_disp.c
    packages/LVGL-v8.2.0/env_support/rt-thread/: lv_rt_thread_port.c
  group STM32_HAL
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_spi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_cortex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_i2c.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_cryp.c stm32h7xx_hal_usart.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pwr_ex.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
