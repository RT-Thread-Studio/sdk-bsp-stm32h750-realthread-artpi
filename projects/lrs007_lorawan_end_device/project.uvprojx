# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32H750xx, USE_HAL_DRIVER, RT_USING_ARM_LIBC
  c include: applications;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\port;board\CubeMX_Config\Core\Inc;libraries\drivers;libraries\drivers\include;libraries\drivers\include\config;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;packages\littled-latest\inc;packages\lora_radio_driver-v1.3.0\lora-radio;packages\lora_radio_driver-v1.3.0\lora-radio\include;packages\lora_radio_driver-v1.3.0\lora-radio\common;packages\lora_radio_driver-v1.3.0\ports;packages\lora_radio_driver-v1.3.0\ports\lora-module\inc;packages\lora_radio_driver-v1.3.0\samples;packages\lorawan_ed_stack-v1.0.3\lorawan-ed-stack\Mac;packages\lorawan_ed_stack-v1.0.3\lorawan-ed-stack\Mac\Crypto;packages\lorawan_ed_stack-v1.0.3\samples;packages\lorawan_ed_stack-v1.0.3\lorawan-ed-stack\Aps\Basic;packages\lorawan_ed_stack-v1.0.3\lorawan-ed-stack\Common;packages\lorawan_ed_stack-v1.0.3\lorawan-ed-stack\Phy;packages\multi_rtimer-v1.1.0\multi_rtimer;packages\multi_rtimer-v1.1.0\ports\stm32_rtc_adapter;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;libraries\STM32H7xx_HAL\CMSIS\Include;rt-thread\components\utilities\ulog
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\STM32H750XBHx\link.sct
  group Applications
    applications/: main.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    board/: board.c drv_mpu.c
    board/port/: filesystem.c
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    libraries/drivers/: drv_common.c drv_usart.c drv_gpio.c drv_spi.c drv_sdio.c drv_wlan.c drv_sdram.c drv_lcd.c drv_rtc.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c
  group littled
    packages/littled-latest/src/: littled.c
  group lora-radio-driver
    packages/lora_radio_driver-v1.3.0/lora-radio/sx126x/: lora-radio-sx126x.c lora-spi-sx126x.c sx126x.c
    packages/lora_radio_driver-v1.3.0/lora-radio/common/: lora-radio-timer.c
  group lora-radio-driver/board
    packages/lora_radio_driver-v1.3.0/ports/lora-module/stm32_adapter/: lora-spi-board.c
    packages/lora_radio_driver-v1.3.0/ports/lora-module/stm32_adapter/SX1268_LSD4RF-2R717N40/: sx1268-board.c
  group lora-radio-driver/sample
    packages/lora_radio_driver-v1.3.0/samples/lora-radio-test-shell/: lora-radio-test-shell.c
  group loramac-ed-stack/mac
    packages/lorawan_ed_stack-v1.0.3/lorawan-ed-stack/Mac/: LoRaMac.c LoRaMacAdr.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
    packages/lorawan_ed_stack-v1.0.3/lorawan-ed-stack/Mac/Crypto/: aes.c cmac.c soft-se.c
  group lorawan-ed-stack/app/samples
    packages/lorawan_ed_stack-v1.0.3/samples/lorawan-ed-shell/: lorawan-ed-test-shell.c
  group lorawan-ed-stack/aps
    packages/lorawan_ed_stack-v1.0.3/lorawan-ed-stack/Aps/Basic/: lorawan-ed-aps.c
  group lorawan-ed-stack/common
    packages/lorawan_ed_stack-v1.0.3/lorawan-ed-stack/Common/: utilities.c
  group lorawan-ed-stack/phy/region
    packages/lorawan_ed_stack-v1.0.3/lorawan-ed-stack/Phy/region/: Region.c RegionCommon.c RegionCN470S.c
  group multi_rtimer
    packages/multi_rtimer-v1.1.0/multi_rtimer/: multi_rtimer.c
    packages/multi_rtimer-v1.1.0/ports/stm32_rtc_adapter/: hw_rtc_stm32.c
  group STM32_HAL
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
