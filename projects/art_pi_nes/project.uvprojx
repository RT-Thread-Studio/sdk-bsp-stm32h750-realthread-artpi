# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H750xx, LFS_CONFIG=lfs_config.h, USE_HAL_DRIVER, RT_USING_ARM_LIBC
  c include: applications;applications\font;applications\img;applications\nes;libraries\audio;packages\CmBacktrace-latest;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\audio;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;board;board\port;board\CubeMX_Config\Core\Inc;libraries\drivers;libraries\drivers\include;libraries\drivers\include\config;packages\fal-v0.5.0\inc;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\dfs\filesystems\romfs;rt-thread\components\finsh;packages\ft6236-latest\inc;packages\gbk2utf8-latest\inc;packages\helix-v1.0.0\pub;packages\helix-v1.0.0\real;.;rt-thread\include;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;packages\littlefs-v2.0.5;packages\LittlevGL2RTT-latest;packages\LittlevGL2RTT-latest\lvgl;packages\LittlevGL2RTT-latest\lvgl\lv_core;packages\LittlevGL2RTT-latest\lvgl\lv_draw;packages\LittlevGL2RTT-latest\lvgl\lv_hal;packages\LittlevGL2RTT-latest\lvgl\lv_misc;packages\LittlevGL2RTT-latest\lvgl\lv_font;packages\LittlevGL2RTT-latest\lvgl\lv_widgets;packages\LittlevGL2RTT-latest\lvgl\lv_themes;packages\nes-latest;packages\nes-latest\inc;packages\nes-latest\src;packages\nes-latest\port;libraries\samples;libraries\Persimmon\inc;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;libraries\STM32H7xx_HAL\CMSIS\Include;rt-thread\components\drivers\touch;rt-thread\components\drivers\include;rt-thread\components\utilities\ymodem
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\STM32H750XBHx\link.sct
  group Applications
    applications/: main.c touch.c ui_control.c ui_home.c ui_nes.c ui_nes_list.c
    applications/font/: lv_fonr_nes_14.c
    applications/img/: img_A.c img_B.c img_cancel.c img_down.c img_left.c img_logo.c img_right.c img_select.c img_start.c img_up.c
    applications/nes/: nes_key_port.c nes_lcd_port.c nes_sound_port.c
  group Audio
    libraries/audio/: drv_sound.c wm8988.c
  group cm_backtrace
    packages/CmBacktrace-latest/: cm_backtrace.c cmb_flash_log.c cmb_port.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/audio/: audio.c audio_pipe.c
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    board/: board.c drv_mpu.c
    board/port/: filesystem.c
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    libraries/drivers/: drv_common.c drv_usart.c drv_gpio.c drv_spi.c drv_sdio.c drv_wlan.c drv_sdram.c drv_lcd.c drv_spi_ili9488.c drv_soft_i2c.c drv_spi_flash.c
  group fal
    packages/fal-v0.5.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-v0.5.0/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    rt-thread/components/dfs/filesystems/elmfat/option/: cc936.c
    rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group ft6236
    packages/ft6236-latest/src/: ft6236.c
  group GBK2UTF8
    packages/gbk2utf8-latest/src/: gbk2utf8.c
  group Helix
    packages/helix-v1.0.0/: mp3dec.c mp3tabs.c
    packages/helix-v1.0.0/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    packages/helix-v1.0.0/real/arm/: asmmisc_rvds.s asmpoly_thumb2_rvds.s
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c
  group littlefs
    packages/littlefs-v2.0.5/: dfs_lfs.c lfs.c lfs_crc.c lfs_util.c
  group LittlevGL2RTT
    packages/LittlevGL2RTT-latest/: littlevgl2rtt.c
    packages/LittlevGL2RTT-latest/lvgl/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    packages/LittlevGL2RTT-latest/lvgl/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    packages/LittlevGL2RTT-latest/lvgl/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    packages/LittlevGL2RTT-latest/lvgl/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    packages/LittlevGL2RTT-latest/lvgl/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c
    packages/LittlevGL2RTT-latest/lvgl/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
    packages/LittlevGL2RTT-latest/lvgl/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
  group nes
    packages/nes-latest/src/: InfoNES.c InfoNES_Mapper.c InfoNES_pAPU.c K6502.c
    packages/nes-latest/src/mapper/: InfoNES_Mapper_000.cpp InfoNES_Mapper_001.cpp InfoNES_Mapper_002.cpp InfoNES_Mapper_003.cpp InfoNES_Mapper_004.cpp InfoNES_Mapper_005.cpp InfoNES_Mapper_006.cpp InfoNES_Mapper_007.cpp InfoNES_Mapper_008.cpp InfoNES_Mapper_009.cpp InfoNES_Mapper_010.cpp InfoNES_Mapper_011.cpp InfoNES_Mapper_013.cpp InfoNES_Mapper_015.cpp InfoNES_Mapper_016.cpp InfoNES_Mapper_017.cpp InfoNES_Mapper_018.cpp InfoNES_Mapper_019.cpp InfoNES_Mapper_021.cpp InfoNES_Mapper_022.cpp InfoNES_Mapper_023.cpp InfoNES_Mapper_024.cpp InfoNES_Mapper_025.cpp InfoNES_Mapper_026.cpp InfoNES_Mapper_032.cpp InfoNES_Mapper_033.cpp InfoNES_Mapper_034.cpp InfoNES_Mapper_040.cpp InfoNES_Mapper_041.cpp InfoNES_Mapper_042.cpp InfoNES_Mapper_043.cpp InfoNES_Mapper_044.cpp InfoNES_Mapper_045.cpp InfoNES_Mapper_046.cpp InfoNES_Mapper_047.cpp InfoNES_Mapper_048.cpp InfoNES_Mapper_049.cpp InfoNES_Mapper_050.cpp InfoNES_Mapper_051.cpp InfoNES_Mapper_057.cpp InfoNES_Mapper_058.cpp InfoNES_Mapper_060.cpp InfoNES_Mapper_061.cpp InfoNES_Mapper_062.cpp InfoNES_Mapper_064.cpp InfoNES_Mapper_065.cpp InfoNES_Mapper_066.cpp InfoNES_Mapper_067.cpp InfoNES_Mapper_068.cpp InfoNES_Mapper_069.cpp InfoNES_Mapper_070.cpp InfoNES_Mapper_071.cpp InfoNES_Mapper_072.cpp InfoNES_Mapper_073.cpp InfoNES_Mapper_074.cpp InfoNES_Mapper_075.cpp InfoNES_Mapper_076.cpp InfoNES_Mapper_077.cpp InfoNES_Mapper_078.cpp InfoNES_Mapper_079.cpp InfoNES_Mapper_080.cpp InfoNES_Mapper_082.cpp InfoNES_Mapper_083.cpp InfoNES_Mapper_085.cpp InfoNES_Mapper_086.cpp InfoNES_Mapper_087.cpp InfoNES_Mapper_088.cpp InfoNES_Mapper_089.cpp InfoNES_Mapper_090.cpp InfoNES_Mapper_091.cpp InfoNES_Mapper_092.cpp InfoNES_Mapper_093.cpp InfoNES_Mapper_094.cpp InfoNES_Mapper_095.cpp InfoNES_Mapper_096.cpp InfoNES_Mapper_097.cpp InfoNES_Mapper_099.cpp InfoNES_Mapper_100.cpp InfoNES_Mapper_101.cpp InfoNES_Mapper_105.cpp InfoNES_Mapper_107.cpp InfoNES_Mapper_108.cpp InfoNES_Mapper_109.cpp InfoNES_Mapper_110.cpp InfoNES_Mapper_112.cpp InfoNES_Mapper_113.cpp InfoNES_Mapper_114.cpp InfoNES_Mapper_115.cpp InfoNES_Mapper_116.cpp InfoNES_Mapper_117.cpp InfoNES_Mapper_118.cpp InfoNES_Mapper_119.cpp InfoNES_Mapper_122.cpp InfoNES_Mapper_133.cpp InfoNES_Mapper_134.cpp InfoNES_Mapper_135.cpp InfoNES_Mapper_140.cpp InfoNES_Mapper_151.cpp InfoNES_Mapper_160.cpp InfoNES_Mapper_180.cpp InfoNES_Mapper_181.cpp InfoNES_Mapper_182.cpp InfoNES_Mapper_183.cpp InfoNES_Mapper_185.cpp InfoNES_Mapper_187.cpp InfoNES_Mapper_188.cpp InfoNES_Mapper_189.cpp InfoNES_Mapper_191.cpp InfoNES_Mapper_193.cpp InfoNES_Mapper_194.cpp InfoNES_Mapper_200.cpp InfoNES_Mapper_201.cpp InfoNES_Mapper_202.cpp InfoNES_Mapper_222.cpp InfoNES_Mapper_225.cpp InfoNES_Mapper_226.cpp InfoNES_Mapper_227.cpp InfoNES_Mapper_228.cpp InfoNES_Mapper_229.cpp InfoNES_Mapper_230.cpp InfoNES_Mapper_231.cpp InfoNES_Mapper_232.cpp InfoNES_Mapper_233.cpp InfoNES_Mapper_234.cpp InfoNES_Mapper_235.cpp InfoNES_Mapper_236.cpp InfoNES_Mapper_240.cpp InfoNES_Mapper_241.cpp InfoNES_Mapper_242.cpp InfoNES_Mapper_243.cpp InfoNES_Mapper_244.cpp InfoNES_Mapper_245.cpp InfoNES_Mapper_246.cpp InfoNES_Mapper_248.cpp InfoNES_Mapper_249.cpp InfoNES_Mapper_251.cpp InfoNES_Mapper_252.cpp InfoNES_Mapper_255.cpp
    packages/nes-latest/port/: nes_embed.c nes_file_port.c
  group STM32_HAL
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_qspi.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_sd.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_nor.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group Touch
    rt-thread/components/drivers/touch/: touch.c
  group Utilities
    rt-thread/components/utilities/ymodem/: ymodem.c
