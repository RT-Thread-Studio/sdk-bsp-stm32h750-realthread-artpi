# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32H750xx, USE_HAL_DRIVER, RT_USING_ARM_LIBC
  c include: packages\ali-iotkit-v3.0.1\iotkit-embedded\src\infra;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\mqtt\impl;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\mqtt;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\dev_model;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\dev_model\client;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\dev_model\server;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\dev_sign;packages\ali-iotkit-v3.0.1\iotkit-embedded\wrappers;applications;..\..\rt-thread\components\net\at\include;..\..\rt-thread\components\net\at\at_socket;packages\at_device-v2.0.4\inc;packages\at_device-v2.0.4\class\l610;packages\cJSON-v1.0.2;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\libcpu\arm\cortex-m7;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\spi;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;board;board\port;board\CubeMX_Config\Core\Inc;..\..\libraries\drivers;..\..\libraries\drivers\include;..\..\libraries\drivers\include\config;..\..\rt-thread\components\dfs\include;..\..\rt-thread\components\dfs\filesystems\devfs;..\..\rt-thread\components\finsh;.;..\..\rt-thread\include;..\..\rt-thread\components\libc\compilers\armlibc;..\..\rt-thread\components\libc\compilers\common;packages\mbedtls-v2.7.10.1\mbedtls\include;packages\mbedtls-v2.7.10.1\ports\inc;..\..\rt-thread\components\net\netdev\include;..\..\libraries\samples;..\..\rt-thread\components\net\sal_socket\include;..\..\rt-thread\components\net\sal_socket\include\socket;..\..\rt-thread\components\net\sal_socket\impl;..\..\rt-thread\components\net\sal_socket\include\dfs_net;..\..\rt-thread\components\net\sal_socket\include\dfs_net\sys_select;..\..\rt-thread\components\net\sal_socket\include\socket\sys_socket;..\..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;..\..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\..\libraries\STM32H7xx_HAL\CMSIS\Include;packages\webclient-v2.1.2\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\STM32H750XBHx\link.sct
  group ali-iotkit
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/infra/: infra_defs.c infra_cjson.c infra_compat.c infra_log.c infra_net.c infra_prt_nwk_payload.c infra_report.c infra_sha256.c infra_string.c infra_timer.c
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/mqtt/: mqtt_api.c
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/mqtt/impl/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c iotx_mqtt_client.c
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/dev_model/client/: dm_client.c dm_client_adapter.c
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/dev_model/: dm_api.c dm_cota.c dm_fota.c dm_ipc.c dm_manager.c dm_message_cache.c dm_message.c dm_opt.c dm_ota.c dm_msg_process.c dm_utils.c iotx_cm_mqtt.c impl_linkkit.c iotx_cm.c dm_log_report.c
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/dev_sign/: dev_sign_mqtt.c
    packages/ali-iotkit-v3.0.1/ports/rtthread/: HAL_OS_rtthread.c HAL_TCP_rtthread.c HAL_UDP_rtthread.c
    packages/ali-iotkit-v3.0.1/ports/: wrapper.c
    packages/ali-iotkit-v3.0.1/iotkit-embedded/certs/: root_ca.c
    packages/ali-iotkit-v3.0.1/ports/tls/mbedtls/: HAL_TLS_mbedtls.c
    packages/ali-iotkit-v3.0.1/samples/mqtt/: mqtt-example.c
  group Applications
    applications/: main.c
  group AT
    ../../rt-thread/components/net/at/src/: at_utils.c at_cli.c at_client.c
    ../../rt-thread/components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-v2.0.4/src/: at_device.c
    packages/at_device-v2.0.4/class/l610/: at_device_l610.c at_socket_l610.c
    packages/at_device-v2.0.4/samples/: at_sample_l610.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON.c cJSON_port.c cJSON_util.c
  group cpu
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group DeviceDrivers
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/rtc/: rtc.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    ../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    board/: board.c drv_mpu.c
    board/port/: filesystem.c
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    ../../libraries/drivers/: drv_common.c drv_usart.c drv_gpio.c drv_spi.c drv_sdio.c drv_wlan.c drv_sdram.c drv_lcd.c
  group Filesystem
    ../../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group finsh
    ../../rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Kernel
    ../../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../../rt-thread/components/libc/compilers/common/: time.c
  group mbedtls
    packages/mbedtls-v2.7.10.1/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    packages/mbedtls-v2.7.10.1/ports/src/: aes_alt.c arc4_alt.c des_alt.c md5_alt.c rsa_alt.c sha1_alt.c sha256_alt.c sha512_alt.c timing_alt.c tls_certificate.c tls_client.c tls_hardware.c tls_net.c
  group netdev
    ../../rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../rt-thread/components/net/sal_socket/src/: sal_socket.c
    ../../rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../rt-thread/components/net/sal_socket/impl/: af_inet_at.c proto_mbedtls.c
    ../../rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group STM32_HAL
    ../../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    ../../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c
    ../../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group WebClient
    packages/webclient-v2.1.2/src/: webclient.c
    packages/webclient-v2.1.2/samples/: webclient_get_sample.c webclient_post_sample.c
