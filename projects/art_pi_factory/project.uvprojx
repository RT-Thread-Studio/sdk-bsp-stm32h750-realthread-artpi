# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32H750xx, LFS_CONFIG=lfs_config.h, USE_HAL_DRIVER, RT_USING_ARM_LIBC
  c include: packages\adbd-v1.1.1\inc;packages\adbd-v1.1.1\services;applications;packages\cJSON-v1.0.2;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\libcpu\arm\cortex-m7;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\spi;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\spi\sfud\inc;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\wlan;board;board\port;board\CubeMX_Config\Core\Inc;..\..\libraries\drivers;..\..\libraries\drivers\include;..\..\libraries\drivers\include\config;packages\EasyFlash-v4.1.0\inc;packages\fal-v0.5.0\inc;..\..\rt-thread\components\dfs\include;..\..\rt-thread\components\dfs\filesystems\devfs;..\..\rt-thread\components\dfs\filesystems\elmfat;..\..\rt-thread\components\dfs\filesystems\romfs;..\..\rt-thread\components\finsh;.;..\..\rt-thread\include;..\..\rt-thread\components\libc\compilers\armlibc;..\..\rt-thread\components\libc\compilers\common;..\..\rt-thread\components\libc\termios;packages\littlefs-v2.0.5;..\..\rt-thread\components\net\lwip-2.0.2\src;..\..\rt-thread\components\net\lwip-2.0.2\src\include;..\..\rt-thread\components\net\lwip-2.0.2\src\include\ipv4;..\..\rt-thread\components\net\lwip-2.0.2\src\arch\include;..\..\rt-thread\components\net\lwip-2.0.2\src\include\netif;modules\basic;modules\bt_module;modules\json_common;modules\monitor;modules\web;modules\wifi;..\..\rt-thread\components\net\netdev\include;packages\netutils-v1.2.0\ntp;..\..\rt-thread\components\libc\pthreads;..\..\rt-thread\components\libc\time;..\..\libraries\rt_ota_lib\inc;packages\btstack-v0.0.1;packages\btstack-v0.0.1\src;packages\btstack-v0.0.1\example\inc;packages\btstack-v0.0.1\platform\posix;packages\btstack-v0.0.1\chipset\bcm;packages\btstack-v0.0.1\port\posix-h4-bcm;packages\btstack-v0.0.1\rtt_adapter;..\..\rt-thread\components\net\sal_socket\include;..\..\rt-thread\components\net\sal_socket\include\socket;..\..\rt-thread\components\net\sal_socket\impl;..\..\rt-thread\components\net\sal_socket\include\dfs_net;..\..\rt-thread\components\net\sal_socket\include\dfs_net\sys_select;..\..\rt-thread\components\net\sal_socket\include\socket\sys_socket;..\..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;..\..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\..\libraries\STM32H7xx_HAL\CMSIS\Include;..\..\rt-thread\components\utilities\ymodem;packages\webnet-v2.0.2\inc;..\..\libraries\wlan_wiced_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\STM32H750XBHx\link.sct
  group adb
    packages/adbd-v1.1.1/core/: adb.c adb_pque.c adb_service.c adbusb.c transport.c transport_socket.c transport_usb.c
    packages/adbd-v1.1.1/services/: file_sync_service.c
  group Applications
    applications/: main.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON.c cJSON_port.c cJSON_util.c
  group cpu
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group DeviceDrivers
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/mtd/: mtd_nor.c
    ../../rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    ../../rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread/components/drivers/wlan/: wlan_dev.c wlan_mgnt.c wlan_cmd.c wlan_prot.c wlan_lwip.c wlan_cfg.c wlan_workqueue.c
  group Drivers
    board/: board.c drv_mpu.c
    board/port/: ef_fal_port.c filesystem.c wifi_config.c
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    ../../libraries/drivers/: drv_common.c drv_usart.c drv_gpio.c drv_spi.c drv_sdio.c drv_wlan.c drv_sdram.c drv_lcd.c
  group EasyFlash
    packages/EasyFlash-v4.1.0/src/: easyflash.c ef_cmd.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
  group fal
    packages/fal-v0.5.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-v0.5.0/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ../../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
    ../../rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group finsh
    ../../rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Kernel
    ../../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../../rt-thread/components/libc/compilers/common/: time.c
    ../../rt-thread/components/libc/termios/: posix_termios.c
  group littlefs
    packages/littlefs-v2.0.5/: dfs_lfs.c lfs.c lfs_crc.c lfs_util.c
  group lwIP
    ../../rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group Modules
    modules/basic/: basic.c
    modules/bt_module/: bt_module.c
    modules/json_common/: json_create_comm.c
    modules/monitor/: monitor.c
    modules/web/: web.c
    modules/wifi/: wifi.c
  group netdev
    ../../rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group NetUtils
    packages/netutils-v1.2.0/ntp/: ntp.c
  group pthreads
    ../../rt-thread/components/libc/pthreads/: mqueue.c pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c semaphore.c
    ../../rt-thread/components/libc/time/: clock_time.c posix_sleep.c
  group rt_ota
    ../../libraries/rt_ota_lib/src/: rtota_update.c
    ../../libraries/rt_ota_lib/libs/: librt_ota_armcm7_noalgo_0.2.3_keil.lib
  group RTT_BTSTACK
    packages/btstack-v0.0.1/platform/posix/: btstack_stdin_posix.c btstack_uart_block_posix.c btstack_tlv_posix.c btstack_run_loop_posix.c
    packages/btstack-v0.0.1/rtt_adapter/: rtt_btstack_gatt_blufi.c rtt_btstack_adapter.c
    packages/btstack-v0.0.1/chipset/bcm/: btstack_chipset_bcm.c btstack_chipset_bcm_download_firmware.c
    packages/btstack-v0.0.1/src/: btstack_util.c btstack_run_loop.c btstack_tlv.c hci_dump.c hci_cmd.c ad_parser.c btstack_linked_list.c btstack_crypto.c hci.c l2cap.c l2cap_signaling.c btstack_memory.c btstack_memory_pool.c hci_transport_h4.c
    packages/btstack-v0.0.1/src/classic/: btstack_link_key_db_tlv.c
    packages/btstack-v0.0.1/src/ble/: le_device_db_tlv.c att_server.c sm.c att_dispatch.c att_db.c
    packages/btstack-v0.0.1/src/ble/gatt-service/: battery_service_server.c
    packages/btstack-v0.0.1/port/posix-h4-bcm/: btstack_main.c
  group SAL
    ../../rt-thread/components/net/sal_socket/src/: sal_socket.c
    ../../rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    ../../rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group STM32_HAL
    ../../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    ../../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_sd.c stm32h7xx_hal_nor.c
    ../../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group Utilities
    ../../rt-thread/components/utilities/ymodem/: ymodem.c
  group WebNet
    packages/webnet-v2.0.2/src/: webnet.c wn_mimetype.c wn_request.c wn_session.c wn_utils.c wn_module.c
    packages/webnet-v2.0.2/module/: wn_module_cgi.c
  group WICED
    ../../libraries/wlan_wiced_lib/: libwifi_6212_armcm7_2.1.2_armcc.lib
