<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\M25P64_STM3210E-EVAL.ewp</path>
  </project>
  <batchBuild/>
</workspace>


