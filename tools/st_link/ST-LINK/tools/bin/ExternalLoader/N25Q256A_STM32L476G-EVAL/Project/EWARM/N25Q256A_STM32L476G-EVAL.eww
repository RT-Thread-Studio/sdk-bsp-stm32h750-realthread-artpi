<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\N25Q256A_STM32L476G-EVAL.ewp</path>
  </project>
  <batchBuild/>
</workspace>


