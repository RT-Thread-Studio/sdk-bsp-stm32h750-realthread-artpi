<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IS61WV51216BLL_STM3210E-EVAL.ewp</path>
  </project>
  <batchBuild/>
</workspace>


