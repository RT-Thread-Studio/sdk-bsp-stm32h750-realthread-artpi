# IAR project IS61WV51216BLL_STM3210E-EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: STM32F10X_XL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\Includes\Library_Files; ..\..\Includes\Loader_Files
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IS61WV51216BLL_STM3210E-EVAL.srec
  postbuild: cmd.exe /C copy ".\Output\Exe\$TARGET_BNAME$.out" "..\..\..\$TARGET_BNAME$.stldr"
  ILINK.IlinkOutputFile: IS61WV51216BLL_STM3210E-EVAL.out
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkExtraOptions: --no_remove
  ILINK.IlinkProgramEntryLabel: Init
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Loader
    ../../Sources/Loader_Files/: Dev_Inf.c Loader_Src.c
  group STM32F10x
    ../../Sources/Library_Files/: stm3210e_eval_fsmc_sram.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c system_stm32f10x.c
